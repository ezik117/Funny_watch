<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Clock_for_children_prj.ewp</path>
    </project>
    <batchBuild />
</workspace>
