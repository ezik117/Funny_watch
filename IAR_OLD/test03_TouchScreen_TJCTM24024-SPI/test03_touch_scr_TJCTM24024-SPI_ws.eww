<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\test03_touch_scr_TJCTM24024-SPI_prj.ewp</path>
  </project>
  <batchBuild/>
</workspace>


